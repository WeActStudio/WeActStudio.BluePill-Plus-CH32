# Keil uVision project usb_cdc_acm.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb_cdc_acm +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CH32F103\CMSIS;..\CH32F103\StdPeriphDriver\inc;..\CH32F103\Debug;..\Inc;..\CherryUSB\common;..\CherryUSB\core;..\CherryUSB\port\fsdev;..\CherryUSB\class\cdc;..\CherryUSB\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Src/: ch32f10x_it.c main.c system_ch32f10x.c board.c
  group Debug
    ../CH32F103/Debug/: debug.c
  group StdPeriphDriver
    ../CH32F103/StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_usb_host.c ch32f10x_wwdg.c
  group Startup
    ../CH32F103/Startup/: startup_ch32f10x.s
  group CherryUSB/app
    ../CherryUSB/app/: usb_config.h cdc_acm_template.c
  group CherryUSB/core
    ../CherryUSB/core/: usbd_core.c
  group CherryUSB/port/fsdev
    ../CherryUSB/port/fsdev/: usb_dc_fsdev.c
  group CherryUSB/class/cdc
    ../CherryUSB/class/cdc/: usbd_cdc.c
